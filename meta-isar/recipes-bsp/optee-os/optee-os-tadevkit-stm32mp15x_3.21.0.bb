#
# Copyright (c) Siemens AG, 2023
#
# SPDX-License-Identifier: MIT

inherit optee-os-tadevkit

require optee-os-stm32mp15x_${PV}.inc
