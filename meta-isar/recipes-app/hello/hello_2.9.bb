# Example recipe to rebuild a debian source package
#
# This software is a part of ISAR.
# Copyright (c) Siemens AG, 2019
#
# SPDX-License-Identifier: MIT

require hello.inc
