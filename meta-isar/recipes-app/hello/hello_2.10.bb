# Example recipe to rebuild a debian source package
#
# This software is a part of ISAR.
# Copyright (c) Siemens AG, 2019
#
# SPDX-License-Identifier: MIT

require hello.inc

DEFAULT_PREFERENCE_debian-buster = "1"
DEFAULT_PREFERENCE_debian-stretch = "1"
