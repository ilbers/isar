inherit buildroot

do_build() {
	echo "Hello"
}
