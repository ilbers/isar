do_test() {
    echo OK
    echo ${LAYERDIR_isar}
}

addtask test before do_build
