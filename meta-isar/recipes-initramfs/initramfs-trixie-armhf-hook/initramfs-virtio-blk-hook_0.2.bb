# This software is a part of Isar.
# Copyright (C) 2026 ilbers GmbH
#
# SPDX-License-Identifier: MIT

require initramfs-missing-hook.inc

MISSING_DRIVER = "virtio_blk"
