# This software is a part of Isar.
# Copyright (C) Siemens

# avoid creating a dedicated sbuild chroot
SBUILD_FLAVOR = ""
