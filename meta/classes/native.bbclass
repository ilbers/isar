# This software is a part of ISAR.
# Copyright (C) 2023 Siemens AG
#
# SPDX-License-Identifier: MIT

################################################################################
# package recipe modifications when building *-native:
################################################################################

PACKAGE_ARCH:class-native = "${HOST_ARCH}"
